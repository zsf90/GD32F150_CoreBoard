# Keil uVision project led_blink.uvprojx, settings and files
target LED_Blink (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F150C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_blink
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F130_150,DEBUG
  c include: .\GD32F1x0_Firmware_Library\CMSIS\GD\GD32F1x0\Include;.\GD32F1x0_Firmware_Library\GD32F1x0_standard_peripheral\Include;.\GD32F1x0_Firmware_Library\CMSIS;.\User\Inc;.\GD32F1x0_Firmware_Library\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./User/Src/: debug_printf.c gd32f1x0_it.c main.c systick.c
  group CMSIS
    ./GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
    ./GD32F1x0_Firmware_Library/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
  group Peripherals
    ./GD32F1x0_Firmware_Library/GD32F1x0_standard_peripheral/Source/: gd32f1x0_exti.c gd32f1x0_gpio.c gd32f1x0_syscfg.c gd32f1x0_usart.c gd32f1x0_rcu.c gd32f1x0_misc.c
  group Utilities
    ./GD32F1x0_Firmware_Library/Utilities/: gd32f1x0r_eval.c
